# Repository lou12de39r/ashiyu

File README.md:

# Ashiyu（足湯）— tomtho-slim mk2: layout v20 and board plan

**Ashiyu（足湯）** — tomtho-slim mk2 の愛称。Designed by tommys079.
Inspired by [ClickBoard](https://salicylic-acid3.hatenablog.com/) by Salicylic_acid3（自作キーボード温泉街）. Keycap models are derived from ACC Keycaps (CC BY-NC 4.0).

This repository holds the frozen layout and the board plan for the second keyboard: roBa-style column stagger, centre trackpad, thin case.

| File | Contents |
|---|---|
| `layout_v20.py` | Script that draws the layout (`roba_ortho_v20.png`) |
| `layout_v20.json` | Fixed coordinates of every key, the trackpad and the LEDs (mm; origin is the rear-left corner of the outline, +y towards the user) |
| `freeze.py` | Regenerates the JSON above from `layout_v20.py` |
| `ORDER.md` | 発注手順: JLCPCB の基板と実装, JLC3DP のケース |
| `case/` | ケース: 上フレームと底板 (CadQuery)。出力は `case-results` ブランチ |
| `layout_v20_print_A4.pdf` / `print11.py` | 1:1 print sheet (A4 landscape). Print at **actual size / 100%** and check the 100 mm bar with a ruler |

## Settled specification

### Layout
- **Keys:** 66 total (v22: lower-left Ctrl 1u, Fn / Win 0.5u stacked, Alt 1u, mirroring the arrow cluster).
  - Left block: 6 columns × number row + 3 rows, plus Fn / Ctrl→**Alt** (firmware) / Win.
  - Right block: 6 columns × number row + 3 rows, plus arrows (← ↑↓ →; ↑ and ↓ are stacked 0.5u keys).
  - Thumbs (v21): 3 per side — outer 1u, **middle (Space / Enter) 1.25u**, inner 1u — at 1.1u spacing. Fan is half of roBa's: tilt 0 / 4.5 / 10°, drop 0 / 0.8 / 3.5 mm.
  - Centre: mouse L / R (1u × 0.5u) and M (0.5u × 0.5u), 2.5 mm below the trackpad window (v21).
  - Rear strip, top-left: BT key (0.5u × 0.5u; tap = next profile, 1 s hold = clear and re-pair).
- **Pitch:** 18.5 × 18.0 mm.
- **Column stagger (v21):** 0.75 × roBa's offsets (was 0.5). Relative to the pinky column: ring 5.0, middle 8.3, index 6.6, inner 4.8 mm towards the rear. The trackpad top lines up with the tops of T / Y; the MCU module, USB-C and charger sit in the free area above it (nothing is stacked under the trackpad).
- **Outline:** 277.0 × 107.5 mm.
- **Trackpad:** Azoteq **TPS43-201A-S** module, 43 × 40 mm (window centred in the 51 mm centre gap, top aligned with T / Y). The keys did not move when the pad shrank from 49 × 42.
- **LEDs:**
  - BT1–3, green: light for 3 s on a press; blink while waiting to pair.
  - Power, yellow-green/red bicolour XL-2012SURSYGC (firmware): green for 3 s on power-up and on a profile switch; below 20 % a short red blink every 5 s.
  - Charge, orange: driven directly by the charger STAT pin; lights only while USB is connected.

### Matrix and GPIO (draft)

| Row | Left side (C0–C5) | Right side (C6–C11) |
|---|---|---|
| R0 | ` 1 2 3 4 5 | 6 7 8 9 0 - |
| R1 | Tab Q W E R T | Y U I O P [ |
| R2 | Ctl A S D F G | H J K L ' ] |
| R3 | ⇧ Z X C V B | N M , . / Ent |
| R4 | Fn Alt Win 変換 Space 無変換 | BS Enter Del ← ↑ → |
| R5 | BT L M R ↓ (5 keys) | — |

**Pin budget:**

| Function | Pins |
|---|---|
| Matrix (6 rows + 12 columns) | 18 |
| BT LEDs | 3 |
| Power LED | 2 |
| Trackpad (SDA, SCL, RDY, RST) | 4 |
| **Total** | **27** |

Charger STAT is **not** wired to the MCU: the MCP73831 drives STAT up to VBUS (5 V) when charging is done, which would overdrive an nRF GPIO. Firmware can see USB power from the nRF's own VBUS detection instead.

The MDBT50Q has room to spare. Reset, NFC and crystal pins are avoided.

### Trackpad (decided: Azoteq TPS43-201A-S module)
- **Module:** IQS572, 43 × 40 mm, PCB 1.0 mm, ships with 3M 468 adhesive (0.13 mm) for sticking to the underside of an overlay. 1.65–3.6 V, I²C. Ordering code: hardware rev 2 = **ZIF connector** (J1) on the module.
- **J1 pinout (datasheet table 2.1):** 1 RDY, 2 NRST, 3 GND, 4 VDDHI, 5 SCL, 6 SDA. The main board's J3 uses the same numbering.
- **Mounting:** stuck under the case-top window; its underside parts hang into a 44 × 41 mm cut-out in the main board, so the pad sits flush with the case top.
- **Cable:** 6-pin FFC from the module's ZIF to J3 (HC-FPC-05-10-6RLTAG, 0.5 mm). **Unchecked:** the module ZIF's pitch, position and contact side. Choose cable type A or B so that pin 1 reaches pin 1 (a mirrored cable swaps GND and VDD).
- **Gestures:** XY for up to 5 fingers; the IQS572 does 1- and 2-finger gestures itself (two-finger scroll). Three-finger swipe = app switch, done in the firmware driver from the touch coordinates (hold Alt, Tab / Shift+Tab per 8–10 mm, release Alt on lift).
- **Supply (2026-10-08):** Mouser 0 in stock, 170 due 10/28/2026, $4.57 each.
- **Alternative:** the GR-Trackpad65-derived IQS550 board in `trackpad/` (49 × 43, hand-soldered IC) is kept, but it no longer fits the 44 × 41 cut-out.

## Schematic (mk2-0.1)

- **Files:** `tomtho_mk2.kicad_sch` (KiCad 9). `gen/build_sch.py` regenerates it from `gen/design.py`, which in turn reads `layout_v20.json`. CI ERC: **0 errors, 0 warnings**. The netlist re-extracted from the schematic matches `design.py`.
- **Matrix:** drawn as a wired grid, COL → SW → D → ROW.
- **Charge LED:** red KT-0603R, driven straight from the charger STAT pin.
- **Footprints:** USB-C, bicolour LED and FPC come from the LCSC/EasyEDA data (`gen/lcsc/`). Bicolour LED pins: 1 = R−, 2 = R+, 3 = YG−, 4 = YG+.

## PCB (mk2-0.1)

- **Board:** `tomtho_mk2.kicad_pcb`, 2 layers, 276 × 107 mm.
- **Build pipeline:**
  1. `gen/route.py` writes a Specctra DSN and runs Freerouting. GND is routed as a normal net (a tree), then poured on both layers.
  2. `gen/post.py` adds about 600 GND stitching vias.
  3. `gen/build_pcb.py` writes the board, fills the zones and runs KiCad DRC.
- **Check:** DRC with schematic parity gives **0 violations, 0 unconnected, 0 parity** in both local KiCad 10 and CI KiCad 9.
- **Fab files:** JLC BOM/CPL are in `jlc/`. CI exports the Gerbers and drill files to `ci-results:gerber`.
- **USB-C:** top-mount HRO TYPE-C-31-M-12 (C165948). It sits in the free area, so the mid-mount part is not needed.
- **Trackpad cut-out:** 44 × 41 mm for the TPS43, J3 and the I²C pull-ups to its left.
- **ACC keycaps:** their four corner legs come down to 1.5 mm above the PCB (0.5 mm when pressed). The ↑ / ↓ diodes and J3 were moved clear of these leg zones (r 2 mm at the corners minus 1.7 mm).
- **Case mounting (no screws):** 9 × Tadpole Pin D3.0 holes (H1–H9, NPTH Ø 3.1): 4 rear, 2 front, 3 centre (both sides below the trackpad and between the inner thumbs). The case is screwless (hidden spring clips).
- **References:** reset switch SW101, power switch SW102, Schottky D101 (SW1–SW66 / D1–D66 are the keys).
- **JLC placement (CPL):**
  - `gen/jlcrot.py` lays each LCSC/EasyEDA footprint (the one JLC places at 0°) over ours and works out the rotation offset and origin shift. `jlc/*_CPL.csv` already includes them, in the Gerber coordinates (+Y up, as `kicad-cli pcb export pos`).
  - Verified: with the CPL as written, every LCSC pad lands on our pad (≤ 0.2 mm) for every part, including the tilted thumb keys.
  - Offsets applied: SOT-23 +180°; SOT-23-5 / SOT-23-6 +270°; USB-C origin 1.57 mm; MDBT50Q origin 1.70 mm.
  - Checked by pin function rather than pad number: the KT-0603R LED (LCSC pad 2 = K) and the SKRA / TS-1928-B switches (joined pairs 1-2 / 3-4).
  - Still look at JLC's preview once before paying.
- **Charge current:** R3 = 4.7 kΩ → about 210 mA (0.2–0.5 C for an 800–1000 mAh cell; use ≥ 420 mAh).
- **Before ordering, check:**
  - **MDBT50Q-1MV2 (C5118826) stock: LCSC showed 0 (2026-10-08).** If JLC has none either, use pre-order / global sourcing, or send the modules in yourself.
  - **Battery polarity:** J2 pin 1 = + (VBAT). LiPo leads with JST SH plugs come both ways round; check with a meter before plugging in (reversed = charger and MCU destroyed).
  - Board thickness **1.2 mm** must be chosen in the order form.
  - The routing is automatic and rough in places; it could be tidied by hand.
- **Firmware must:**
  - Set UICR REGOUT0 to 3.0 V. The module runs from VDDH, and the erased default is 1.8 V, at which the LEDs (Vf ≈ 1.9–2.0 V) stay dark.
  - Enable pin reset on P0.18.
  - Drive the LEDs active-low (cathode to GPIO).

## Parts check (2026-10-07, LCSC / JLCPCB pages)

| Part | Result |
|---|---|
| IQS550BLQNR (C5271144) | **Out of stock at LCSC.** The trackpad board cannot be assembled at JLC as planned |
| USB-C TYPE-C 16PIN 2MD(073) (C2765186) | In stock, but right-angle SMD, not mid-mount. Not used |
| **USB-C SHOU HAN TYPE-C 16P CB1.6 073 (C2906290)** | **Use this.** Mid-mount (sinks 1.6 mm), 16-pin, 6.5 mm long, plentiful stock (LCSC). JLC rates assembly difficulty "High". It is made for a 1.6 mm board, so on our 1.2 mm board it sticks out about 0.4 mm below → add a pocket in the case bottom |
| FPC 0.5 mm 6-pin HC-FPC-05-10-6RLTAG (C5213729) | In stock (5k), bottom contact, flip lock |
| Green LED 19-217/GHC (C72043) | Vf 3.3 V: **too high for a 3.0 V VDD**. Needs a yellow-green (≈2.0 V) part instead |
| Red LED KT-0603R (C2286) | Vf 1.8–2.4 V, usable |
| Bicolour LED XINGLIGHT XL-2012SURSYGC (C965847) | **Use this.** 2.0 × 1.2 mm, common anode, red + yellow-green (Vf ≈ 2.4 V at 20 mA; lower at 1–2 mA, so it works from 3.0 V). In stock (20k) |
| IQS550-BL-QNR elsewhere | Octopart lists it only at non-authorised resellers (about 1.1k and 32k pcs, $1.7–3.0). Stock at Mouser / DigiKey could not be read (unconfirmed) |

## Verify before ordering (in priority order)
1. **TPS43 connector:** get the drawing (or measure a module): the ZIF's pitch, position and contact side, and the FFC length and type. Pin 1 must reach pin 1.
2. **ZMK driver for the IQS572 / TPS43:** QMK has an Azoteq IQS5xx driver. For ZMK only community drivers exist (unchecked).
3. **Height:** check that the parts in the free area (module about 2.2 mm, USB-C) fit under the case top, and that the TPS43's underside parts clear the cut-out and the case floor.
4. **Keycaps:** fit of the Acid Caps on the tilted thumb keys, checked by laying out the 3D data.
5. **0.5u × 0.5u caps (BT, M):** these are not sold, so they must be made. Print a test piece first.

## KiCad design tomtho_mk2.kicad_pcb

Parts:
C1, C4, C6, C7: 4.7uF; C_0603; MPN CL10A475KO8NNNC; LCSC C19666
C2: 10uF; C_0603; MPN CL10A106KP8NNNC; LCSC C19702
C3, C5: 100nF; C_0603; MPN CC0603KRX7R9BB104; LCSC C14663
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66: 1N4148W; D_SOD-123; MPN 1N4148W; LCSC C81598
D101: B5819W; D_SOD-123; MPN B5819W SL; LCSC C8598
H1, H2, H3, H4, H5, H6, H7, H8, H9: Tadpole; Tadpole_D3.0_NPTH
J1: USB-C; USB_C_HRO_TYPE-C-31-M-12; MPN TYPE-C-31-M-12; LCSC C165948
J2: BATTERY; JST_SH_SM02B-SRSS-TB; MPN SM02B-SRSS-TB(LF)(SN); LCSC C160402
J3: TRACKPAD; FPC_0.5mm_6P_HC; MPN HC-FPC-05-10-6RLTAG; LCSC C5213729
LED1: RED; LED_0603; MPN KT-0603R; LCSC C2286
LED2, LED3, LED4, LED5: XL-2012SURSYGC; LED_XL-2012_Bicolor; MPN XL-2012SURSYGC; LCSC C965847
Q1: AO3401A; SOT-23; MPN AO3401A; LCSC C15127
R1, R2: 5.1k; R_0603; MPN 0603WAF5101T5E; LCSC C23186
R3, R11, R12: 4.7k; R_0603; MPN 0603WAF4701T5E; LCSC C23162
R4, R6, R7, R8, R9, R10: 1k; R_0603; MPN 0603WAF1001T5E; LCSC C21190
R5: 100k; R_0603; MPN 0603WAF1003T5E; LCSC C25803
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW38, SW39, SW40, SW41, SW42, SW43, SW44, SW45, SW46, SW47, SW48, SW49, SW50, SW51, SW52, SW53, SW54, SW55, SW56, SW57, SW58, SW59, SW60, SW61, SW62, SW63, SW64, SW65, SW66: SKRAAWE010; SW_ALPS_SKRA_6.2mm; MPN SKRAAWE010; LCSC C202383
SW101: RESET; SW_TS-1928-B; MPN TS-1928-B; LCSC C1121891
SW102: POWER; SW_SPDT_PCM12; MPN PCM12SMTR; LCSC C221841
TP1: SWDIO; TestPoint_Pad_D1.0mm
TP2: SWCLK; TestPoint_Pad_D1.0mm
TP3: GND; TestPoint_Pad_D1.0mm
TP4: VDD; TestPoint_Pad_D1.0mm
U1: MDBT50Q-1MV2; Raytac_MDBT50Q; MPN MDBT50Q-1MV2; LCSC C5118826
U2: USBLC6-2SC6; SOT-23-6; MPN USBLC6-2SC6; LCSC C7519
U3: MCP73831; SOT-23-5; MPN MCP73831T-2ACI/OT; LCSC C424093

Connections:
/CC1: J1.A5 (CC1), R1.1
/CC2: J1.B5 (CC2), R2.1
/CHG_STAT: LED1.1 (K), U3.1 (STAT)
/COL0: SW1.1, SW13.1, SW25.1, SW37.1, SW49.1, SW61.1, U1.14 (P0.30/AIN6)
/COL1: SW2.1, SW14.1, SW26.1, SW38.1, SW50.1, SW62.1, U1.16 (P0.27)
/COL2: SW3.1, SW15.1, SW27.1, SW39.1, SW51.1, U1.20 (P0.04/AIN2)
/COL3: SW4.1, SW16.1, SW28.1, SW40.1, SW52.1, U1.22 (P0.06)
/COL4: SW5.1, SW17.1, SW29.1, SW41.1, SW53.1, U1.24 (P0.08)
/COL5: SW6.1, SW18.1, SW30.1, SW42.1, SW54.1, SW63.1, U1.26 (P1.09)
/COL6: SW7.1, SW19.1, SW31.1, SW43.1, SW55.1, SW64.1, U1.48 (P0.24)
/COL7: SW8.1, SW20.1, SW32.1, SW44.1, SW56.1, SW65.1, U1.46 (P0.22)
/COL8: SW9.1, SW21.1, SW33.1, SW45.1, SW57.1, U1.44 (P0.20)
/COL9: SW10.1, SW22.1, SW34.1, SW46.1, SW58.1, U1.41 (P0.17)
/COL10: SW11.1, SW23.1, SW35.1, SW47.1, SW59.1, SW66.1, U1.39 (P0.15)
/COL11: SW12.1, SW24.1, SW36.1, SW48.1, SW60.1, U1.37 (P0.13)
/K0_0: D1.2 (A), SW1.2
/K0_1: D2.2 (A), SW2.2
/K0_2: D3.2 (A), SW3.2
/K0_3: D4.2 (A), SW4.2
/K0_4: D5.2 (A), SW5.2
/K0_5: D6.2 (A), SW6.2
/K0_6: D7.2 (A), SW7.2
/K0_7: D8.2 (A), SW8.2
/K0_8: D9.2 (A), SW9.2
/K0_9: D10.2 (A), SW10.2
/K0_10: D11.2 (A), SW11.2
/K0_11: D12.2 (A), SW12.2
/K1_0: D13.2 (A), SW13.2
/K1_1: D14.2 (A), SW14.2
/K1_2: D15.2 (A), SW15.2
/K1_3: D16.2 (A), SW16.2
/K1_4: D17.2 (A), SW17.2
/K1_5: D18.2 (A), SW18.2
/K1_6: D19.2 (A), SW19.2
/K1_7: D20.2 (A), SW20.2
/K1_8: D21.2 (A), SW21.2
/K1_9: D22.2 (A), SW22.2
/K1_10: D23.2 (A), SW23.2
/K1_11: D24.2 (A), SW24.2
/K2_0: D25.2 (A), SW25.2
/K2_1: D26.2 (A), SW26.2
/K2_2: D27.2 (A), SW27.2
/K2_3: D28.2 (A), SW28.2
/K2_4: D29.2 (A), SW29.2
/K2_5: D30.2 (A), SW30.2
/K2_6: D31.2 (A), SW31.2
/K2_7: D32.2 (A), SW32.2
/K2_8: D33.2 (A), SW33.2
/K2_9: D34.2 (A), SW34.2
/K2_10: D35.2 (A), SW35.2
/K2_11: D36.2 (A), SW36.2
/K3_0: D37.2 (A), SW37.2
/K3_1: D38.2 (A), SW38.2
/K3_2: D39.2 (A), SW39.2
/K3_3: D40.2 (A), SW40.2
/K3_4: D41.2 (A), SW41.2
/K3_5: D42.2 (A), SW42.2
/K3_6: D43.2 (A), SW43.2
/K3_7: D44.2 (A), SW44.2
/K3_8: D45.2 (A), SW45.2
/K3_9: D46.2 (A), SW46.2
/K3_10: D47.2 (A), SW47.2
/K3_11: D48.2 (A), SW48.2
/K4_0: D49.2 (A), SW49.2
/K4_1: D50.2 (A), SW50.2
/K4_2: D51.2 (A), SW51.2
/K4_3: D52.2 (A), SW52.2
/K4_4: D53.2 (A), SW53.2
/K4_5: D54.2 (A), SW54.2
/K4_6: D55.2 (A), SW55.2
/K4_7: D56.2 (A), SW56.2
/K4_8: D57.2 (A), SW57.2
/K4_9: D58.2 (A), SW58.2
/K4_10: D59.2 (A), SW59.2
/K4_11: D60.2 (A), SW60.2
/K5_0: D61.2 (A), SW61.2
/K5_1: D62.2 (A), SW62.2
/K5_5: D63.2 (A), SW63.2
/K5_6: D64.2 (A), SW64.2
/K5_7: D65.2 (A), SW65.2
/K5_10: D66.2 (A), SW66.2
/LED_BT1: R6.2, U1.5 (P1.12)
/LED_BT1_K: LED2.3 (YG-), R6.1
/LED_BT2: R7.2, U1.7 (P1.14)
/LED_BT2_K: LED3.3 (YG-), R7.1
/LED_BT3: R8.2, U1.9 (P0.03/AIN1)
/LED_BT3_K: LED4.3 (YG-), R8.1
/LED_CHG_A: LED1.2 (A), R4.2
/LED_PWR_G: R9.2, U1.11 (P0.02/AIN0)
/LED_PWR_GK: LED5.3 (YG-), R9.1
/LED_PWR_R: R10.2, U1.13 (P0.28/AIN4)
/LED_PWR_RK: LED5.1 (R-), R10.1
/PROG: R3.1, U3.5 (PROG)
/RESET: SW101.1, U1.40 (P0.18/RESET)
/ROW0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), U1.3 (P1.10)
/ROW1: D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), U1.4 (P1.11)
/ROW2: D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), U1.6 (P1.13)
/ROW3: D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), D48.1 (K), U1.8 (P1.15)
/ROW4: D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), D60.1 (K), U1.10 (P0.29/AIN5)
/ROW5: D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), D65.1 (K), D66.1 (K), U1.12 (P0.31/AIN7)
/SWCLK: TP2.1, U1.53 (SWDCLK)
/SWDIO: TP1.1, U1.51 (SWDIO)
/TP_RDY: J3.1 (RDY), U1.42 (P0.19)
/TP_RST: J3.2 (RST), U1.43 (P0.21)
/TP_SCL: J3.5 (SCL), R12.2, U1.38 (P0.16)
/TP_SDA: J3.6 (SDA), R11.2, U1.36 (P0.14)
/USB_DN: J1.A7 (D-), J1.B7 (D-), U1.34 (D-), U2.3 (I/O2), U2.4 (I/O2)
/USB_DP: J1.A6 (D+), J1.B6 (D+), U1.35 (D+), U2.1 (I/O1), U2.6 (I/O1)
/VBAT: C7.1, J2.1 (BAT+), Q1.3 (D), U3.3 (VBAT)
/VBUS: C1.1, C6.1, D101.2 (A), J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), Q1.1 (G), R4.1, R5.1, U1.32 (VBUS), U2.5 (VBUS), U3.4 (VDD)
/VDD: C4.1, C5.1, J3.4 (VDD), LED2.2 (R+), LED2.4 (YG+), LED3.2 (R+), LED3.4 (YG+), LED4.2 (R+), LED4.4 (YG+), LED5.2 (R+), LED5.4 (YG+), R11.1, R12.1, TP4.1, U1.28 (VDD)
/VDDH: C2.1, C3.1, SW102.1 (A), U1.30 (VDDH)
/VSYS: D101.1 (K), Q1.2 (S), SW102.2 (C)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.2 (BAT-), J3.3 (GND), J3.MP, R1.2, R2.2, R3.2, R5.2, SW101.2, TP3.1, U1.1 (GND), U1.2 (GND), U1.15 (GND), U1.33 (GND), U1.55 (GND), U2.2 (GND), U3.2 (VSS)

Notes on the sheet:
tomtho-slim mk2 - 65 keys, roBa-style half stagger, centre trackpad (Azoteq TPS43 module) ALPS SKRA 6.2mm / 18.5 x 18 mm pitch / nRF52840 (Raytac MDBT50Q-1MV2, TELEC) / 1S LiPo + USB-C / ZMK
MCU (REG0 LDO mode: DCCH open, VDDH = system rail)
Module decoupling (place at pins)
Reset (double-tap = UF2) / SWD pads
USB-C mid-mount (5.1k CC pull-downs = sink)
Charger MCP73831 Ichg = 1000V / R3 = 100 mA LED1 = charging (VBUS powered)
Load sharing (AN1149) USB -> D101, battery -> Q1 SW102: VSYS -> VDDH
Battery 1S LiPo (protected)
Indicator LEDs: bicolour, anode = VDD, GPIO sinks (active low) LED2-4 = BT1-3 (green die) / LED5 = power (green OK, red < 20 %)
Trackpad module (Azoteq TPS43) FPC 6P 0.5 mm, I2C pull-ups here
Case screws (M2, from below into the top frame)
GPIO map (ZMK, diode-direction = col2row) rows: ROW0=P1.10, ROW1=P1.11, ROW2=P1.13, ROW3=P1.15, ROW4=P0.29/AIN5, ROW5=P0.31/AIN7 cols: COL0=P0.30/AIN6, COL1=P0.27, COL2=P0.04/AIN2, COL3=P0.06, COL4=P0.08, COL5=P1.09 COL6=P0.24, COL7=P0.22, COL8=P0.20, COL9=P0.17, COL10=P0.15, COL11=P0.13 LED (activ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
Key matrix 6 x 12 (66 keys, ALPS SKRA + 1N4148W, COL -> SW -> D -> ROW)
Tab
Ctl
Ent
Ctrl
Alt
変換 L6
Space L2
無変換 L3
Enter L1
Del
BT 切替
Win

Board: 2 copper layers, 275.8 x 106.3 mm, 179 parts (0 on the bottom side), 114 nets.

File jlc/tomtho_mk2_BOM.csv:

Comment,Designator,Footprint,LCSC Part #,Qty,MPN,Note
4.7uF,"C1,C4,C6,C7",C_0603,C19666,4,CL10A475KO8NNNC,16V X5R
10uF,C2,C_0603,C19702,1,CL10A106KP8NNNC,10V X5R
100nF,"C3,C5",C_0603,C14663,2,CC0603KRX7R9BB104,50V X7R
1N4148W,"D1,D2,D3,D4,D5,D6,D7,D8,D9,D10,D11,D12,D13,D14,D15,D16,D17,D18,D19,D20,D21,D22,D23,D24,D25,D26,D27,D28,D29,D30,D31,D32,D33,D34,D35,D36,D37,D38,D39,D40,D41,D42,D43,D44,D45,D46,D47,D48,D49,D50,D51,D52,D53,D54,D55,D56,D57,D58,D59,D60,D61,D62,D63,D64,D65,D66",D_SOD-123,C81598,66,1N4148W,Switching diode
B5819W,D101,D_SOD-123,C8598,1,B5819W SL,VBUS -> VSYS
USB-C,J1,USB_C_HRO_TYPE-C-31-M-12,C165948,1,TYPE-C-31-M-12,"USB2.0 Type-C receptacle, top mount (sits in the free area under the case top)"
BATTERY,J2,JST_SH_SM02B-SRSS-TB,C160402,1,SM02B-SRSS-TB(LF)(SN),"LiPo 1S (protected cell), check polarity!"
TRACKPAD,J3,FPC_0.5mm_6P_HC,C5213729,1,HC-FPC-05-10-6RLTAG,To Azoteq TPS43 trackpad module (FFC 6P 0.5 mm)
RED,LED1,LED_0603,C2286,1,KT-0603R,Charge indicator (on while charging)
XL-2012SURSYGC,"LED2,LED3,LED4,LED5",LED_XL-2012_Bicolor,C965847,4,XL-2012SURSYGC,"BT1 profile LED (yellow-green die used, red unused)"
AO3401A,Q1,SOT-23,C15127,1,AO3401A,Battery -> VSYS when no USB
5.1k,"R1,R2",R_0603,C23186,2,0603WAF5101T5E,CC pull-down
4.7k,"R3,R11,R12",R_0603,C23162,3,0603WAF4701T5E,Ichg = 1000V/4.7k = 213mA (0.2-0.5C for an 800-1000 mAh cell)
1k,"R4,R6,R7,R8,R9,R10",R_0603,C21190,6,0603WAF1001T5E,LED resistor
100k,R5,R_0603,C25803,1,0603WAF1003T5E,Q1 gate pull-down
SKRAAWE010,"SW1,SW2,SW3,SW4,SW5,SW6,SW7,SW8,SW9,SW10,SW11,SW12,SW13,SW14,SW15,SW16,SW17,SW18,SW19,SW20,SW21,SW22,SW23,SW24,SW25,SW26,SW27,SW28,SW29,SW30,SW31,SW32,SW33,SW34,SW35,SW36,SW37,SW38,SW39,SW40,SW41,SW42,SW43,SW44,SW45,SW46,SW47,SW48,SW49,SW50,SW51,SW52,SW53,SW54,SW55,SW56,SW57,SW58,SW59,SW60,SW61,SW62,SW63,SW64,SW65,SW66",SW_ALPS_SKRA_6.2mm,C202383,66,SKRAAWE010,"key ""`"" - ALPS SKRA 6.2mm tact"
RESET,SW101,SW_TS-1928-B,C1121891,1,TS-1928-B,Reset (double-tap = UF2 bootloader)
POWER,SW102,SW_SPDT_PCM12,C221841,1,PCM12SMTR,"Power slide switch (pin3 = OFF, open)"
MDBT50Q-1MV2,U1,Raytac_MDBT50Q,C5118826,1,MDBT50Q-1MV2,"nRF52840 BLE module, chip antenna, TELEC certified"
USBLC6-2SC6,U2,SOT-23-6,C7519,1,USBLC6-2SC6,USB ESD protection
MCP73831,U3,SOT-23-5,C424093,1,MCP73831T-2ACI/OT,Li-Po charger 4.2V

## KiCad design trackpad/tp_crop.kicad_pcb

File trackpad/README.md:

# tomtho-slim mk2 trackpad (49 × 43 mm, IQS550, 10 Tx × 10 Rx)

This board is derived from **GR-Trackpad65** by geek-rabb1t (MIT License, see `LICENSE_GR-Trackpad65`; original files in `src_grt65/`).

GR-Trackpad65 is 65 × 49 mm with 15 Tx × 10 Rx. Its electrode pitch is 4.2 mm (Tx) × 4.7 mm (Rx). Keeping 10 Tx columns gives exactly 42 mm, so **the electrode shape, pitch and IC surroundings are reused as they are**. Only the board was cut down.

## Changes from the original
1. **Cut down to Tx5–Tx14.** Tx0–Tx4 and the PCBA rails are removed. With the 0.6 mm frame, the board is **49.1 × 43.1 mm**, 4 layers, 1.6 mm thick (same as the original).
   - The case window is 49 × 42 mm. The extra 1.1 mm sits under the case top, towards the L/R buttons.
2. **Rx series resistors R9–R12 moved.** They were on the part that was cut off. Rx6–Rx9 were re-routed on B.Cu (Freerouting with a custom single-layer DSN). Rx7–Rx9 also got new vias onto their F.Cu Rx lines.
3. **Rotated 90°** so the board fits the layout (49 wide × 43 tall). The FFC connector J1 is on the back, at +9.43 / +18.09 mm from the top-left corner, with its opening facing −x.
4. **KiCad 10 DRC: 0 errors, 0 unconnected.**
   - Remaining warnings: footprint-library differences, and silkscreen near the board edge.

## Not done / needs checking (in priority order)
1. **IQS550 settings.** A freshly mounted IQS550 does not work as a trackpad.
   - The original's hex file is written for 15 Tx, so it **cannot be used as-is**.
   - Settings needed:
     - Total Tx = 10.
     - Tx mapping = IC pins Tx5–Tx14.
     - Rx mapping is unchanged.
     - Resolution, and so on.
   - Two ways to write them:
     - (a) Write and save them with Azoteq's CT210A programmer and the IQS5xx-B000 GUI.
     - (b) Write them over I2C at every boot from the ZMK driver. **(b) is planned.** No extra tool is needed, but whether every register is writable at run time still has to be checked against the datasheet (uncertain).
2. **The QFN pads were not lengthened.**
   - Lengthening them shorts them to the dense original fan-out traces.
   - Hand soldering assumes **solder paste + hotplate or hot air**. The pads are the standard KiCad QFN-48 7×7 footprint.
   - JLC assembles everything except U1. The CPL/BOM leave U1 out.
3. **Overlay.** The original recommends **2 mm matte acrylic**. Other materials need different settings.
4. **Thickness and mounting.** The trackpad sits in a **cut-out in the main board** and rests on the case floor:
   - case floor 0.5 + clearance for the back-side parts (FFC connector about 2 mm)
   - \+ PCB 1.6 + overlay 2.0
   - ≈ the case top.
5. **FFC.**
   - Cable: 6-pin, 0.5 mm pitch, length about 15 mm, **contacts on opposite sides (type B)**.
   - Main board J3 is arranged so each pad faces the same signal at the same height.
   - Check continuity before fitting.

## Files
| File | Contents |
|---|---|
| `tomtho_mk2_trackpad.kicad_pcb` | Finished board |
| `jlc/*_BOM.csv`, `*_CPL.csv` | For JLC PCBA, assembled on the back side, U1 left out |
| `gen/crop.py` → `gen/route_b.py` → `gen/trim.py` → `gen/finish.py` | Build steps (KiCad Python + Freerouting) |
| `src_grt65/` | Original GR-Trackpad65 data (MIT) |

Board: 4 copper layers, 43.0 x 49.0 mm, 20 parts (20 on the bottom side), 17 nets.

Parts:
C1, C6: 100n; C_0603_1608Metric
C2, C4: 100p; C_0603_1608Metric
C3, C5: 1u; C_0603_1608Metric
J1: Conn_01x06; Jushuo_AFC07-S06FCA-00_1x6-1MP_P0.50_Horizontal-JLC
R1, R2: 4.7k; R_0603_1608Metric
R3, R4, R5, R6, R7, R8, R9, R10, R11, R12: 1k; R_0603_1608Metric
U1: IQS550; QFN-48-1EP_7x7mm_P0.5mm_EP3.5x3.5mm

Connections:
+3V3: C1.1, C2.1, C3.1, J1.4, R1.1, R2.1, U1.7 (VDDHI), U1.38 (VDDIO)
/NRST: C6.1, J1.2, U1.10 (NRST)
/RDY: J1.1, U1.11 (RDY)
/SCL: J1.5, R1.2, U1.6 (SCL)
/SDA: J1.6, R2.2, U1.5 (SDA)
/VREG: C4.1, C5.1, U1.9 (VREG)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, J1.3, U1.8 (VSS), U1.37 (VSSIO), U1.49 (TAB)
unnamed: R3.2, U1.13 (Rx0A)
unnamed: R4.2, U1.15 (Rx1A)
unnamed: R5.2, U1.17 (Rx2A)
unnamed: R6.2, U1.19 (Rx3A)
unnamed: R7.2, U1.21 (Rx4A)
unnamed: R8.2, U1.23 (Rx5A)
unnamed: R9.1, U1.25 (Rx6A)
unnamed: R10.1, U1.27 (Rx7A)
unnamed: R11.1, U1.29 (Rx8A)
unnamed: R12.1, U1.31 (Rx9A)

File trackpad/jlc/tomtho_mk2_trackpad_BOM.csv:

Comment,Designator,Footprint,LCSC Part #,Qty
100n,"C1,C6",C_0603_1608Metric,C14663,2
100p,"C2,C4",C_0603_1608Metric,C14858,2
1u,"C3,C5",C_0603_1608Metric,C15849,2
Conn_01x06,J1,Jushuo_AFC07-S06FCA-00_1x6-1MP_P0.50_Horizontal-JLC,C11048,1
4.7k,"R1,R2",R_0603_1608Metric,C23162,2
1k,"R3,R4,R5,R6,R7,R8,R9,R10,R11,R12",R_0603_1608Metric,C21190,10
